LR_BOOT 0x08000000 0x5000 {
 ER_BOOT 0x08000000 0x5000 {
  startup.o (RESET, +First)
  *(InRoot$$Sections)
  .ANY (+RO)
 }
 RW_RAM 0x20000000 0x24000 { .ANY (+RW +ZI) }
}
